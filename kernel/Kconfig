## kernel/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
config GPU_PTR_TRANSLATOR
    tristate "gpu ptr translator"
    help
```
